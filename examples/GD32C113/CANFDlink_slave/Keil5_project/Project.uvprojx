# Keil uVision project Project.uvprojx, settings and files
target GD32C11X (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32C113CB GigaDevice
  pack: GigaDevice.GD32C11x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32C11X
  c include: ..\Libraries\CMSIS;..\Libraries\CMSIS\GD\GD32C11x\Include;..\Libraries\GD32C11x_standard_peripheral\Include;..\Bsp;..\App;..\CANFDlink\inc;..\Utils;..\CANFDlink\inc\port
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../Libraries/CMSIS/GD/GD32C11x/Source/: system_gd32c11x.c
    ../Libraries/CMSIS/GD/GD32C11x/Source/ARM/: startup_gd32c11x.s
  group Libraries
    ../Libraries/GD32C11x_standard_peripheral/Source/: gd32c11x_adc.c gd32c11x_bkp.c gd32c11x_can.c gd32c11x_crc.c gd32c11x_ctc.c gd32c11x_dac.c gd32c11x_dbg.c gd32c11x_dma.c gd32c11x_exmc.c gd32c11x_exti.c gd32c11x_fmc.c gd32c11x_fwdgt.c gd32c11x_gpio.c gd32c11x_i2c.c gd32c11x_misc.c gd32c11x_pmu.c gd32c11x_rcu.c gd32c11x_rtc.c gd32c11x_spi.c gd32c11x_timer.c gd32c11x_usart.c gd32c11x_wwdgt.c
  group Bsp
    ../Bsp/: bsp_led.c bsp_systick.c bsp_can.c
  group CANFDlink/port
    ../CANFDlink/inc/port/: canfdlink_port.h
  group CANFDlink/src
    ../CANFDlink/src/: modbus_registers.c modbus_common.c modbus_canfd_slave.c
  group App
    ../App/: gd32c11x_it.c main.c CANFDlinkConfig.h
  group Utils
    ../Utils/: data_convert.c crc16.c
